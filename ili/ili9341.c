 

#include "ili9341.h"

 
static const unsigned char FONT_8x16[10][16] = {
    {   0x00, 0x00, 0x38, 0x6C, 0xC6, 0xC6, 0xD6, 0xD6, 0xC6, 0xC6, 0xC6, 0x6C, 0x38, 0x00, 0x00, 0x00 },
    {   0x00, 0x00, 0x38, 0x58, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x7E, 0x00, 0x00, 0x00 },
    {   0x00, 0x00, 0x78, 0xCC, 0x86, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFE, 0x00, 0x00, 0x00 },
    {   0x00, 0x00, 0x78, 0xCC, 0x06, 0x06, 0x0C, 0x38, 0x0C, 0x06, 0x06, 0x8E, 0x7C, 0x00, 0x00, 0x00 },
    {   0x00, 0x00, 0x0C, 0x1C, 0x3C, 0x2C, 0x6C, 0xCC, 0x8C, 0xFE, 0x0C, 0x0C, 0x0C, 0x00, 0x00, 0x00 },
    {   0x00, 0x00, 0xFC, 0xC0, 0xC0, 0xC0, 0xF8, 0x8C, 0x06, 0x06, 0x06, 0x8C, 0x78, 0x00, 0x00, 0x00 },
    {   0x00, 0x00, 0x3C, 0x64, 0xC0, 0xC0, 0xFC, 0xE6, 0xC6, 0xC6, 0xC6, 0x66, 0x3C, 0x00, 0x00, 0x00 },
    {   0x00, 0x00, 0xFE, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x30, 0x20, 0x00, 0x00, 0x00 },
    {   0x00, 0x00, 0x7C, 0x46, 0xC6, 0xC6, 0x44, 0x7C, 0xC6, 0xC6, 0xC6, 0xC6, 0x7C, 0x00, 0x00, 0x00 },
    {   0x00, 0x00, 0x78, 0xCC, 0xC6, 0xC6, 0xC6, 0xCE, 0x7E, 0x06, 0x06, 0x4C, 0x78, 0x00, 0x00, 0x00 },
};

static const unsigned char FONT_BLANK[16] = {
    0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
};

 
static uint16_t g_lcd_fg = LCD_FG_COLOR;
static uint16_t g_lcd_bg = LCD_BG_COLOR;

 
static const unsigned char FONT_UPPER[26][16] = {
    {   0x00, 0x0C, 0x0C, 0x0C, 0x1C, 0x1E, 0x1E, 0x1E, 0x36, 0x3E, 0x36, 0x33, 0x63, 0x63, 0x63, 0x00 },
    {   0x00, 0x7C, 0x6C, 0x66, 0x66, 0x66, 0x6C, 0x7C, 0x6C, 0x66, 0x66, 0x66, 0x66, 0x6C, 0x7C, 0x00 },
    {   0x00, 0x3C, 0x36, 0x63, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x63, 0x36, 0x3C, 0x00 },
    {   0x00, 0x7C, 0x6C, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x7C, 0x00 },
    {   0x00, 0x7F, 0x60, 0x60, 0x60, 0x60, 0x60, 0x7E, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x7F, 0x00 },
    {   0x00, 0x7F, 0x60, 0x60, 0x60, 0x60, 0x60, 0x7E, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x00 },
    {   0x00, 0x3C, 0x36, 0x66, 0x63, 0x60, 0x60, 0x60, 0x60, 0x6F, 0x63, 0x63, 0x63, 0x33, 0x3F, 0x00 },
    {   0x00, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x7F, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x00 },
    {   0x00, 0x7F, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x7F, 0x00 },
    {   0x00, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x3C, 0x00 },
    {   0x00, 0x66, 0x6C, 0x6C, 0x78, 0x70, 0x70, 0x60, 0x78, 0x6C, 0x66, 0x66, 0x66, 0x63, 0x63, 0x00 },
    {   0x00, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x7F, 0x00 },
    {   0x00, 0x66, 0x66, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x00 },
    {   0x00, 0x63, 0x63, 0x73, 0x73, 0x7B, 0x7B, 0x7B, 0x6F, 0x6F, 0x6F, 0x67, 0x67, 0x63, 0x63, 0x00 },
    {   0x00, 0x3C, 0x66, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x36, 0x3C, 0x00 },
    {   0x00, 0x7C, 0x6C, 0x66, 0x66, 0x66, 0x6C, 0x7C, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x00 },
    {   0x00, 0x3C, 0x66, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x6F, 0x67, 0x36, 0x3F, 0x00 },
    {   0x00, 0x7C, 0x6C, 0x66, 0x66, 0x66, 0x6C, 0x7C, 0x70, 0x78, 0x78, 0x6C, 0x66, 0x66, 0x63, 0x00 },
    {   0x00, 0x3C, 0x36, 0x63, 0x60, 0x30, 0x30, 0x1E, 0x06, 0x03, 0x03, 0x63, 0x66, 0x36, 0x3C, 0x00 },
    {   0x00, 0x7F, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x00 },
    {   0x00, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x66, 0x3E, 0x00 },
    {   0x00, 0x63, 0x63, 0x63, 0x63, 0x33, 0x33, 0x36, 0x36, 0x36, 0x36, 0x1E, 0x1E, 0x1E, 0x0C, 0x00 },
    {   0x00, 0x61, 0x61, 0x61, 0x61, 0x61, 0x61, 0x7F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x00 },
    {   0x00, 0x63, 0x63, 0x36, 0x36, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x36, 0x36, 0x63, 0x63, 0x00 },
    {   0x00, 0x63, 0x63, 0x36, 0x36, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00 },
    {   0x00, 0x7F, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x60, 0x7F, 0x00 },
};

 
static const unsigned char FONT_LOWER[26][16] = {
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x36, 0x36, 0x36, 0x36, 0x36, 0x1E, 0x00 },
    {   0x00, 0x00, 0x60, 0x60, 0x60, 0x60, 0x60, 0x7E, 0x66, 0x73, 0x73, 0x73, 0x73, 0x7E, 0x7E, 0x00 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x37, 0x60, 0x60, 0x60, 0x33, 0x3E, 0x00, 0x00 },
    {   0x00, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x3F, 0x33, 0x67, 0x67, 0x67, 0x67, 0x3F, 0x3F, 0x00 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x63, 0x7F, 0x63, 0x63, 0x36, 0x3E, 0x00 },
    {   0x00, 0x00, 0x3C, 0x18, 0x18, 0x18, 0x1C, 0x1E, 0x1E, 0x1B, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x36, 0x63, 0x63, 0x63, 0x63, 0x36, 0x3E, 0x3C },
    {   0x00, 0x00, 0x60, 0x60, 0x60, 0x60, 0x60, 0x7E, 0x66, 0x73, 0x73, 0x73, 0x73, 0x7E, 0x7E, 0x00 },
    {   0x00, 0x00, 0x3C, 0x00, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00 },
    {   0x00, 0x00, 0x1C, 0x00, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x70 },
    {   0x00, 0x00, 0x66, 0x6C, 0x78, 0x70, 0x70, 0x60, 0x70, 0x78, 0x6C, 0x66, 0x66, 0x63, 0x63, 0x00 },
    {   0x00, 0x00, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6D, 0x7F, 0x7F, 0x6D, 0x6D, 0x6D, 0x6D, 0x6D, 0x00 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x66, 0x73, 0x73, 0x73, 0x73, 0x7E, 0x7E, 0x00 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x36, 0x63, 0x63, 0x63, 0x33, 0x36, 0x3E, 0x00 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x66, 0x63, 0x63, 0x63, 0x63, 0x66, 0x7E, 0x18 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x33, 0x63, 0x63, 0x63, 0x63, 0x33, 0x3F, 0x0C },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x6C, 0x66, 0x63, 0x60, 0x60, 0x60, 0x60, 0x00 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x3E, 0x60, 0x30, 0x1E, 0x66, 0x37, 0x3C, 0x00 },
    {   0x00, 0x00, 0x00, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1E, 0x1B, 0x00 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x63, 0x63, 0x63, 0x63, 0x63, 0x73, 0x1E, 0x00 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x63, 0x33, 0x36, 0x36, 0x1E, 0x1E, 0x0C, 0x00 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x61, 0x61, 0x61, 0x61, 0x3F, 0x3F, 0x3F, 0x3F, 0x00 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x36, 0x36, 0x1C, 0x1C, 0x36, 0x36, 0x63, 0x00 },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x63, 0x36, 0x36, 0x36, 0x36, 0x1C, 0x1C, 0x3C },
    {   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x7F, 0x00 },
};

#if LCD_USE_EXTENDED_INIT
 
static const uint8_t INIT_C0[]  = {0x23};
static const uint8_t INIT_C1[]  = {0x10};
static const uint8_t INIT_C5[]  = {0x3E, 0x28};
static const uint8_t INIT_C7[]  = {0x86};
static const uint8_t INIT_B1[]  = {0x00, 0x18};
static const uint8_t INIT_B6[]  = {0x08, 0x82, 0x27};
static const uint8_t INIT_E0[]  = {
    0x0F, 0x31, 0x2B, 0x0C, 0x0E, 0x08, 0x4E, 0xF1,
    0x37, 0x07, 0x10, 0x03, 0x0E, 0x09, 0x00
};
static const uint8_t INIT_E1[]  = {
    0x00, 0x0E, 0x14, 0x03, 0x11, 0x07,
    0x31, 0xC1, 0x48, 0x08, 0x0F, 0x0C, 0x31, 0x36, 0x0F
};
#endif

 
static void delay_ms(uint32_t ms)
{
    volatile uint32_t i;

    while (ms--) {
        for (i = 0; i < 8000U; i++) {
             
        }
    }
}

 
static void spi_write_byte(uint8_t dat)
{
    uint8_t i;

    for (i = 0; i < 8; i++) {
        LCD_SCK_L();
        if (dat & 0x80) { LCD_SDI_H(); } else { LCD_SDI_L(); }
        dat <<= 1;
        LCD_SCK_H();                         
    }
    LCD_SCK_L();
}

 
static void spi_write_const(uint8_t dat)
{
    uint8_t i;

    if (dat == 0xFF) {
        LCD_SDI_H();
    } else if (dat == 0x00) {
        LCD_SDI_L();
    } else {
        spi_write_byte(dat);
        return;
    }
    for (i = 0; i < 8; i++) {
        LCD_SCK_L();
        LCD_SCK_H();
    }
    LCD_SCK_L();
}

static void write_cmd(uint8_t cmd)
{
    LCD_CS_L();
    LCD_DC_L();
    spi_write_byte(cmd);
    LCD_CS_H();
}

 
static void write_cmd_data(uint8_t cmd, const uint8_t *dat, uint8_t n)
{
    LCD_CS_L();
    LCD_DC_L();
    spi_write_byte(cmd);
    LCD_DC_H();
    while (n--) {
        spi_write_byte(*dat++);
    }
    LCD_CS_H();
}

static void ram_start(void)
{
    LCD_CS_L();
    LCD_DC_L();
    spi_write_byte(0x2C);
    LCD_DC_H();
}

static void ram_end(void)
{
    LCD_CS_H();
}

static void set_window(uint16_t x0, uint16_t y0, uint16_t x1, uint16_t y1)
{
    uint8_t p[4];

    p[0] = (uint8_t)(x0 >> 8);
    p[1] = (uint8_t)(x0 & 0xFF);
    p[2] = (uint8_t)(x1 >> 8);
    p[3] = (uint8_t)(x1 & 0xFF);
    write_cmd_data(0x2A, p, 4);

    p[0] = (uint8_t)(y0 >> 8);
    p[1] = (uint8_t)(y0 & 0xFF);
    p[2] = (uint8_t)(y1 >> 8);
    p[3] = (uint8_t)(y1 & 0xFF);
    write_cmd_data(0x2B, p, 4);
}

 
static void gpio_init(void)
{
    uint32_t crl;

    LCD_RCC_APB2ENR |= (1UL << 2);           
    LCD_RCC_APB2ENR &= ~(1UL << 12);          

    crl  = LCD_GPIOA->CRL;
    crl &= ~((0xFUL << 0) | (0xFUL << 4) | (0xFUL << 8) |
             (0xFUL << 20) | (0xFUL << 28));
    crl |=  ((0x3UL << 0) | (0x3UL << 4) | (0x3UL << 8) |
             (0x3UL << 20) | (0x3UL << 28));
#if LCD_LED_CTRL
    crl &= ~(0xFUL << (4UL * LCD_LED_PIN));
    crl |=  (0x3UL << (4UL * LCD_LED_PIN));
#endif
    LCD_GPIOA->CRL = crl;

#if LCD_LED_CTRL
    LCD_LED_H();                             
#endif
    LCD_CS_H();                              
    LCD_RES_H();                              
    LCD_SCK_L();                              
    LCD_DC_H();
    LCD_SDI_L();
}

 
void LCD_Init(void)
{
    uint8_t p[4];

    gpio_init();

    LCD_RES_H();
    delay_ms(20);
    LCD_RES_L();
    delay_ms(20);
    LCD_RES_H();
    delay_ms(120);

    write_cmd(0x01);                         
    delay_ms(100);
    write_cmd(0x11);                         
    delay_ms(120);

     
    p[0] = 0x55;
    write_cmd_data(0x3A, p, 1);              
    p[0] = (uint8_t)LCD_MADCTL_VALUE;
    write_cmd_data(0x36, p, 1);              
    p[0] = 0x01;
    write_cmd_data(0x26, p, 1);              

#if LCD_USE_EXTENDED_INIT
    write_cmd_data(0xB1, INIT_B1, 2);        
    write_cmd_data(0xB6, INIT_B6, 3);        
    write_cmd_data(0xC0, INIT_C0, 1);        
    write_cmd_data(0xC1, INIT_C1, 1);        
    write_cmd_data(0xC5, INIT_C5, 2);        
    write_cmd_data(0xC7, INIT_C7, 1);        
    write_cmd_data(0xE0, INIT_E0, 15);
    write_cmd_data(0xE1, INIT_E1, 15);
#endif

    write_cmd(0x20);                         
    write_cmd(0x13);                         
    write_cmd(0x29);                         
    delay_ms(30);

    LCD_ClearScreen();                       
}

 
void LCD_Fill(uint16_t color)
{
    uint32_t i, total;
    uint8_t hi = (uint8_t)(color >> 8);
    uint8_t lo = (uint8_t)(color & 0xFF);

    total = (uint32_t)LCD_WIDTH * (uint32_t)LCD_HEIGHT;
    set_window(0, 0, LCD_WIDTH - 1, LCD_HEIGHT - 1);
    ram_start();
    for (i = 0; i < total; i++) {
        spi_write_const(hi);
        spi_write_const(lo);
    }
    ram_end();
}

 
static const uint8_t *get_glyph(char ch)
{
    if (ch >= '0' && ch <= '9') return FONT_8x16[ch - '0'];
    if (ch >= 'A' && ch <= 'Z') return FONT_UPPER[ch - 'A'];
    if (ch >= 'a' && ch <= 'z') return FONT_LOWER[ch - 'a'];
    return FONT_BLANK;
}

 
static uint8_t g_lcd_bg_transparent = 1;

void LCD_SetBgTransparent(uint8_t enable)
{
    g_lcd_bg_transparent = enable ? 1u : 0u;
}

 
static void draw_char_transparent(uint16_t x, uint16_t y, const uint8_t *g,
                                  uint16_t fc, uint8_t size)
{
    uint8_t row, col, rep_y, b;
    uint8_t fhi, flo;
    uint16_t cw, chh, run, i;

    if (size == 0) size = 1;
    cw  = (uint16_t)(8 * size);
    chh = (uint16_t)(16 * size);
    if (x + cw > LCD_WIDTH || y + chh > LCD_HEIGHT) return;

    fhi = (uint8_t)(fc >> 8);
    flo = (uint8_t)(fc & 0xFF);

    for (row = 0; row < 16; row++) {
        b = g[row];
        for (rep_y = 0; rep_y < size; rep_y++) {
            uint16_t yy = (uint16_t)(y + row * size + rep_y);
            run = 0;                             
            for (col = 0; col <= 8; col++) {
                if (col < 8 && (b & (uint8_t)(0x80 >> col))) {
                    run++;                       
                } else if (run > 0) {            
                    uint16_t x0 = (uint16_t)(x + (col - run) * size);
                    uint16_t x1 = (uint16_t)(x + col * size - 1);
                    set_window(x0, yy, x1, yy);
                    ram_start();
                    for (i = x0; i <= x1; i++) {
                        spi_write_const(fhi);
                        spi_write_const(flo);
                    }
                    ram_end();
                    run = 0;
                }
            }
        }
    }
}

 
static void draw_char(uint16_t x, uint16_t y, const uint8_t *g,
                      uint16_t fc, uint16_t bc, uint8_t size)
{
    uint8_t row, col, rep_y, rep_x, b;
    uint8_t fhi, flo, bhi, blo;
    uint16_t cw, chh;

    if (size == 0) size = 1;
    cw  = (uint16_t)(8 * size);
    chh = (uint16_t)(16 * size);
    if (x + cw > LCD_WIDTH || y + chh > LCD_HEIGHT) return;

    if (g_lcd_bg_transparent) {                  
        draw_char_transparent(x, y, g, fc, size);
        return;
    }

    fhi = (uint8_t)(fc >> 8);
    flo = (uint8_t)(fc & 0xFF);
    bhi = (uint8_t)(bc >> 8);
    blo = (uint8_t)(bc & 0xFF);

    set_window(x, y, x + cw - 1, y + chh - 1);
    ram_start();
    for (row = 0; row < 16; row++) {
        b = g[row];
        for (rep_y = 0; rep_y < size; rep_y++) {
            for (col = 0; col < 8; col++) {
                for (rep_x = 0; rep_x < size; rep_x++) {
                    if (b & (uint8_t)(0x80 >> col)) {
                        spi_write_const(fhi);
                        spi_write_const(flo);
                    } else {
                        spi_write_const(bhi);
                        spi_write_const(blo);
                    }
                }
            }
        }
    }
    ram_end();
}

 
void LCD_ShowChar(uint16_t x, uint16_t y, char ch,
                  uint16_t fc, uint16_t bc, uint8_t size)
{
    draw_char(x, y, get_glyph(ch), fc, bc, size);
}

 
void LCD_ShowString(uint16_t x, uint16_t y, const char *s,
                    uint16_t fc, uint16_t bc, uint8_t size)
{
    uint8_t sz = size ? size : 1;

    while (*s) {
        LCD_ShowChar(x, y, *s, fc, bc, sz);
        x = (uint16_t)(x + 8 * sz + 2 * sz);
        s++;
    }
}

 
void LCD_ShowCharC(uint16_t x, uint16_t y, char ch, uint16_t fc, uint16_t bc, uint8_t size)
{
    draw_char(x, y, get_glyph(ch), fc, bc, size);
}

 
void LCD_ShowStringAtC(uint16_t x, uint16_t y, const char *s,
                       uint16_t fc, uint16_t bc, uint8_t size)
{
    uint8_t sz = size ? size : 1;

    while (*s) {
        LCD_ShowCharC(x, y, *s, fc, bc, sz);
        x = (uint16_t)(x + 8 * sz + 2 * sz);
        s++;
    }
}

 
void LCD_ShowStringCentered(const char *s, uint16_t fc, uint16_t bc, uint8_t size)
{
    const char *p = s;
    uint16_t n = 0;
    uint16_t x, y, w, h;
    uint8_t sz = size ? size : 1;

    while (*p) { n++; p++; }
    if (n == 0) return;

    w = (uint16_t)(n * (8 * sz + 2 * sz) - 2 * sz);
    h = (uint16_t)(16 * sz);
    x = (w < LCD_WIDTH) ? (uint16_t)((LCD_WIDTH - w) / 2) : 0;
    y = (uint16_t)((LCD_HEIGHT - h) / 2);

    LCD_ShowString(x, y, s, fc, bc, sz);
}

 

 
uint16_t LCD_RGB(uint8_t r, uint8_t g, uint8_t b)
{
    uint16_t rr = (uint16_t)(r >> 3);    
    uint16_t gg = (uint16_t)(g >> 2);    
    uint16_t bb = (uint16_t)(b >> 3);    
    return (uint16_t)((rr << 11) | (gg << 5) | bb);
}

 
void LCD_SetColors(uint16_t fg, uint16_t bg)
{
    g_lcd_fg = fg;
    g_lcd_bg = bg;
}

 
void LCD_ShowStringCenteredC(const char *s, uint8_t size)
{
    LCD_ShowStringCentered(s, g_lcd_fg, g_lcd_bg, size);
}

 
void LCD_ClearScreen(void)
{
    LCD_Fill(g_lcd_bg);
}

 
void LCD_FillArea(uint16_t x, uint16_t y,
                  uint16_t w, uint16_t h, uint16_t color)
{
    uint32_t cnt;
    uint8_t hi, lo;
    uint16_t xend, yend;

    if (w == 0 || h == 0) return;
    if (x >= LCD_WIDTH || y >= LCD_HEIGHT) return;

    xend = (uint16_t)(x + w - 1);
    yend = (uint16_t)(y + h - 1);
    if (xend >= LCD_WIDTH)  xend = LCD_WIDTH  - 1;    
    if (yend >= LCD_HEIGHT) yend = LCD_HEIGHT - 1;    

    hi = (uint8_t)(color >> 8);
    lo = (uint8_t)(color & 0xFF);

    set_window(x, y, xend, yend);
    ram_start();
    for (cnt = (uint32_t)(xend - x + 1) * (uint32_t)(yend - y + 1);
         cnt != 0; cnt--) {
        spi_write_const(hi);
        spi_write_const(lo);
    }
    ram_end();
}

 
void LCD_ShowImage256(uint16_t x, uint16_t y,
                      uint16_t w, uint16_t h,
                      const uint16_t *palette, const uint8_t *img)
{
    uint32_t i, total;
    uint16_t color;

    if (img == 0 || palette == 0 || w == 0 || h == 0) return;
    if (x >= LCD_WIDTH || y >= LCD_HEIGHT) return;

    if ((uint32_t)x + w > LCD_WIDTH)  w = (uint16_t)(LCD_WIDTH  - x);   
    if ((uint32_t)y + h > LCD_HEIGHT) h = (uint16_t)(LCD_HEIGHT - y);   

    set_window(x, y, (uint16_t)(x + w - 1), (uint16_t)(y + h - 1));
    ram_start();
    total = (uint32_t)w * h;
    for (i = 0; i < total; i++) {
        color = palette[img[i]];                     
        spi_write_byte((uint8_t)(color >> 8));       
        spi_write_byte((uint8_t)(color & 0xFF));     
    }
    ram_end();
}

 
